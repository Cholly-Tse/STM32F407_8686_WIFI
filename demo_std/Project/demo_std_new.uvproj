# Keil uVision project demo_std_new.uvproj, settings and files
target demo_std_new (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: demo_std +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE\inc;..\FWLIB\inc;..\HARDWARE\inc;..\LWIP\port\include;..\LWIP\src\include;..\LWIP\src\include\ipv4;..\SDIO\inc;..\USER\inc;..\WIFI\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HARDWARE
    ../HARDWARE/src/: key.c led.c sdio_user.c usart.c tim.c
  group USER
    ../USER/: main.c
    ../USER/src/: delay.c netapp.c parmcfg.c stm32f4xx_it.c sys_user.c system_stm32f4xx.c
  group LWIP
    ../LWIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/src/core/: dhcp.c dhcpsrv.c dns.c init.c mem.c memp.c netbios.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../LWIP/src/netif/: etharp.c
    ../LWIP/port/netif/: ethernetif.c
    ../LWIP/port/: lwIP.c
  group SDIO
    ../SDIO/src/: common.c core.c s3cmci.c sdio.c sdio_bus.c sdio_cis.c sdio_io.c
  group WIFI
    ../WIFI/src/: 11d.c 8686.c assoc.c cmd.c help.c if_sdio.c marvel_main.c marvell_ops.c rx.c scan.c
